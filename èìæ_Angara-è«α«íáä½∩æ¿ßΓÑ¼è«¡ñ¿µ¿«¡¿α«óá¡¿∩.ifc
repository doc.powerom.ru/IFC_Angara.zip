Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Номер проекта
Time: 2022-09-05T10:53:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190225_1515(x64) - Exporter 19.2.10.7 - Альтернативный интерфейс 19.2.10.7
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 05 10:53:12 2022 * Host: Dell * Database: C:\Users\6EDA~1\AppData\Local\Temp\{D51D95DB-1BC2-4549-93FB-6F235EC0A9E8}\ifc * Database version: 5507 * Database creation date: Mon Sep 05 10:53:06 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 05 10:53:06 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 05 10:53:06 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Номер проекта
LongName: Наименование проекта; Phase: П

# IfcSite, Default
RefLatitude: 55, 44, 57, 789001; RefLongitude: 37, 38, 4, 304809; RefElevation: 153650 mm

# IfcBuilding, Наименование здания
LongName: Наименование здания
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
In: Наименование здания
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: Лого, Лого:Лого:757592
In: Этаж 01
Type - Material: DKC_КрасныйЛого
Pset_BuildingElementProxyCommon - Reference: Лого

# IfcBuildingElementProxy: Текст модели:100 мм Arial (69)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 100 мм Arial

# IfcBuildingElementProxy: Текст модели:150 мм Arial (14)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 150 мм Arial

# IfcBuildingElementProxy: Текст модели:300 мм Arial (3)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300 мм Arial

# IfcBuildingElementProxy: Текст модели:600 мм Arial
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 600 мм Arial

# IfcFlowFitting: Ввод в стену (4)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Ввод в стену
Name (КНС_ВводВСтенуПодУглом_DKC:Ввод в стену:...)
749187
789479
789492
789495

# IfcFlowFitting: Левый, КНС_ВводВоВнутреннийБлокКондиционера_DKC:Левый:750874
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Левый

# IfcFlowFitting: Переходники_DKC (4)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Переходники_DKC
Name (КНС_Переходники_DKC:Переходники_DKC:...)
754567
783069
783680
783749

# IfcFlowFitting: Правый, КНС_ВводВоВнутреннийБлокКондиционера_DKC:Правый:754208
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Правый

# IfcFlowFitting: Прямой ввод в стену_DKC (4)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Прямой ввод в стену_DKC
Name (КНС_ПрямойВводВСтену_DKC:Прямой ввод в стену_DKC:...)
779586
789329
789342
789345

# IfcFlowFitting: Стандарт (7)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Стандарт
Name (КНС_Тройник_DKC:Стандарт:...)
754355
785033
785046
785049
785052
785258
785266

# IfcFlowFitting: Стандартное (7)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Стандартное
Name (КНС_Заглушка_DKC:Стандартное:...)
763791
792394
792407
792410
792413
792416
792419

# IfcFlowFitting: Угол внешний (7)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Угол внешний
Name (КНС_Угол_DKC:Угол внешний:...)
754262
786625
786640
786643
786646
786649
786652

# IfcFlowFitting: Угол внутренний (7)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Угол внутренний
Name (КНС_Угол_DKC:Угол внутренний:...)
754276
788057
788077
788080
788083
788086
788089

# IfcFlowFitting: Угол плоский (5)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Угол плоский
Name (КНС_Угол_DKC:Угол плоский:...)
754290
788214
788227
788230
788233

# IfcFlowSegment: Воздуховод прямоугольного сечения:Короб для кондиционера (основание+крышка) ДКС (5)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Короб для кондиционера (основание+крышка) ДКС
Name (Воздуховод прямоугольного сечения:Короб для кондиционера (основание+крышка) ДКС:...)
731951
732241
781134
781135
781276

# IfcFlowSegment: Воздуховод прямоугольного сечения:Короб плинтусного типа ДКС, Воздуховод прямоугольного сечения:Короб плинтусного типа ДКС:740831
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Короб плинтусного типа ДКС

# IfcFlowSegment: Воздуховод прямоугольного сечения:Короб плинтусного типа ламинированный под дерево ДКС, Воздуховод прямоугольного сечения:Короб плинтусного типа ламинированный под дерево ДКС:733155
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Короб плинтусного типа ламинированный под дерево ДКС

# IfcFlowSegment: Воздуховод прямоугольного сечения:Крышка (короба для кондиционеров) ДКС (5)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Крышка (короба для кондиционеров) ДКС
Name (Воздуховод прямоугольного сечения:Крышка (короба для кондиционеров) ДКС:...)
732218
743176
781350
781359
781411

# IfcFlowSegment: Гибкий трубопровод круглого сечения:Шланги дренажные ДКС (12)
In: Этаж 01
Type - PredefinedType: FLEXIBLESEGMENT
Pset_DistributionFlowElementCommon - Reference: Шланги дренажные ДКС
Name (Гибкий трубопровод круглого сечения:Шланги дренажные ДКС:...)
730934
731865
731892
780874
780876
780878
780890
780892
780894
780912
780914
780916
